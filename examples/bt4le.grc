options:
  parameters:
    generate_options: no_gui
    id: bt4le
    output_language: python
    title: bt4le
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: gain_send
  id: variable
  parameters:
    value: '80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: bt4le_preamble_prefixer_0
  id: bt4le_preamble_prefixer
  parameters: {}
  states: {}
- name: bt4le_whitening_0
  id: bt4le_whitening
  parameters:
    chan_nbr: '37'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dev_args: '""'
    gain0: gain_send
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', digital_gmsk_mod_0, '0']
- [blocks_socket_pdu_0, pdus, bt4le_preamble_prefixer_0, in]
- [bt4le_preamble_prefixer_0, out, bt4le_whitening_0, in]
- [bt4le_whitening_0, out, blocks_message_debug_0, print_pdu]
- [bt4le_whitening_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_gmsk_mod_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
